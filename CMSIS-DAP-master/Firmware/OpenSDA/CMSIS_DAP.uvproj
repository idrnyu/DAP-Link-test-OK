# Keil uVision project CMSIS_DAP.uvproj, settings and files
target MK20DX128xxx5 (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: CMSIS_DAP
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  group Startup Code
    ./: startup_MK20D5.s system_MK20D5.c
  group Configuration
    ./: DAP_config.h usb_config.c
  group USB Driver
    ./: usbd_MK20D5.c
  group CMSIS-DAP Core
    ./: main.c usbd_user_hid.c
    ../: DAP.c SW_DP.c JTAG_DP.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
